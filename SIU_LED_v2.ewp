# IAR project SIU_LED_v2.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.PreInclude: global_conf.h
  ICCSTM8.CCIncludePath2: E:\IAR_PROJECT\SIU_LED_v2; E:\IAR_PROJECT\SIU_LED_v2\STM8L15x_StdPeriph_Driver; E:\IAR_PROJECT\SIU_LED_v2\STM8L15x_StdPeriph_Driver\inc; E:\IAR_PROJECT\SIU_LED_v2\STM8L15x_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SIU_LED_v2_С8.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.PreInclude: E:\IAR_PROJECT\SIU_LED_v2\global_conf.h
  ILINK.IlinkOutputFile: SIU_LED_v2.out
  group (top)
    ./: main.c modbus.c pc_communication.c settings.c
  group SPL
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
